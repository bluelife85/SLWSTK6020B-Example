# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG12P332F1024GL125 SiliconLaboratories EFR32BG12P332F1024GL125
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EFR32BG12P332F1024GL125; HAL_CONFIG=1
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..; E:\Silabs\Propertise-Write No Response; E:\Silabs\Propertise-Write No Response\platform\CMSIS\Include; E:\Silabs\Propertise-Write No Response\platform\radio\rail_lib\common; E:\Silabs\Propertise-Write No Response\platform\radio\rail_lib\chip\efr32; E:\Silabs\Propertise-Write No Response\hardware\kit\common\drivers; E:\Silabs\Propertise-Write No Response\hardware\kit\EFR32BG12_BRD4103A\config; E:\Silabs\Propertise-Write No Response\hardware\kit\common\bsp; E:\Silabs\Propertise-Write No Response\platform\emlib\inc; E:\Silabs\Propertise-Write No Response\platform\emdrv\common\inc; E:\Silabs\Propertise-Write No Response\platform\emdrv\gpiointerrupt\inc; E:\Silabs\Propertise-Write No Response\platform\emdrv\sleep\inc; E:\Silabs\Propertise-Write No Response\platform\emdrv\uartdrv\inc; E:\Silabs\Propertise-Write No Response\platform\emdrv\tempdrv\inc; E:\Silabs\Propertise-Write No Response\platform\Device\SiliconLabs\EFR32BG12P\Include; E:\Silabs\Propertise-Write No Response\protocol\bluetooth\ble_stack\inc\common; E:\Silabs\Propertise-Write No Response\protocol\bluetooth\ble_stack\inc\soc; E:\Silabs\Propertise-Write No Response\platform\bootloader\api; E:\Silabs\Propertise-Write No Response\platform\bootloader; E:\Silabs\Propertise-Write No Response\app\bluetooth\common\stack_bridge; E:\Silabs\Propertise-Write No Response\hardware\kit\common\halconfig; E:\Silabs\Propertise-Write No Response\platform\halconfig\inc\hal-config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iar.bin
  ILINK.IlinkOutputFile: soc-empty.out
  ILINK.IlinkIcfFile: ../EFR32BG12P332F1024GL125.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  OBJCOPY.OOCOutputFile: soc-empty.bin
  group (top)
    ../: application_properties.c communication_handler.c gatt_db.c init_app.c init_board.c init_mcu.c main.c pti.c
    ../hardware/kit/common/bsp/: bsp_stk.c
    ../platform/emlib/src/: em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_emu.c em_gpio.c em_i2c.c em_msc.c em_rmu.c em_rtcc.c em_system.c em_usart.c
    ../hardware/kit/common/drivers/: mx25flash_spi.c
    ../platform/emdrv/sleep/src/: sleep.c
    ../platform/Device/SiliconLabs/EFR32BG12P/Source/IAR/: startup_efr32bg12p.c
    ../platform/Device/SiliconLabs/EFR32BG12P/Source/: system_efr32bg12p.c
    ../platform/emdrv/tempdrv/src/: tempdrv.c
  group gattdb
    ../: gatt.xml
  group lib
    ../protocol/bluetooth/lib/EFR32BG12P/IAR/: binapploader.o libbluetooth.a libmbedtls.a libpsstore.a
    ../platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg12_iar_release.a
